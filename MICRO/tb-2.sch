v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {MICRO/LC.sym} -60 0 0 0 {name=x1}
